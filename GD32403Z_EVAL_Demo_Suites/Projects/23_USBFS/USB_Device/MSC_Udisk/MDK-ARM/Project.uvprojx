# Keil uVision project Project.uvprojx, settings and files
target GD32403Z_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F403VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F403
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\device\class\msc\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\class\msc;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\common;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\device\core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c GD32F403_it.c GD32F403_hw.c flash_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_GD32F403.c
  group GD32F403_Peripherals
    ../../../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_ctc.c gd32f403_dma.c gd32f403_exti.c gd32f403_fmc.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c
  group USB_Drivers
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Startup
    ../../../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
